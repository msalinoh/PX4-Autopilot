## src/drivers/distance_sensor/a22_i2c/Kconfig
```kconfig
menuconfig DRIVERS_DISTANCE_SENSOR_A22_I2C
	bool "a22_i2c"
	default n
	---help---
		Enable support for a22_i2c
```
